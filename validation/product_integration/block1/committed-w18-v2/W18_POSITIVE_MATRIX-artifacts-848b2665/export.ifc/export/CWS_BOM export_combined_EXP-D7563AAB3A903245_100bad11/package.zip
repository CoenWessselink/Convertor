Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: SAME_e107266637a1.ifc
Time: 2026-09-12T11:44:06+00:00
Author: CWS Convertor
Organization: CWS Convertor
Written by: CWS Convertor v0.10.19-beta-dev
Made in: CWS Convertor v0.10.19-beta-dev
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 1/3 eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOck5XdHR5MnpnUy9SVVhIM2NsRnlsUm91Ujl5bFROeSs1c1ZXb3pieWtYQ3lSQkNXT1NVQUJRRnVQeWYrei83STl0TndDQ29DNjI0OHRrVWtsTU5uRnBkSisrd2c4QlVZcmsyNW8yU2dZM0Q0K1RnTFFGVTJuRk44SE4xOXRKa1BORzhWYkF4NjhQUVVseUd0d0UrMkFTM0xHbWdNZFAvNExuSFdkNk9vd29pR3Byb0FPMTRTcmZtc2R2d1UxNEhVNENRUXJXU3Z0eVR5dFk0U3MrZS85Z3k0TWU4RGg1dDlWbTRYUHJSZUhQWGhIWHUzMDBBdDlUb2FoSTRZZGt2SUVsdytzSS9xNm5HVlZrV2xDVWY4NjVLRmhERkUxTFFXcFF5MFBBQmR1d0pxM3I4U2E0UVVvT0REVVVqY2hkVDBaUzVNamZmYkw5ZEF2UUtBUzVaODBHdHlJTkhKY29ZRS8yT0tsM3BPbFNxYnFLcGd5eFVkQ1N0SlVDWmdzR0FNT3pwUG1Xc01aQXhld0JaNS8wVWh6UlNncEVnWERySWZnMXZBVzZaQVVTYTliQWkrcDIrR0xtUC9vYnNRSjNDYmE4b3RNd2pLYUhBSmpVYkNGSlRnL1RVdkI2V3RGU1RjMTBoMmtuV00wczBEbG9vcUNnRXRpVXdvaVNWSkxDNWlDQkt2VzN4TWt3bGxRVjdJZndJSm5rVlF0TFBjUFlueWVMdzVRMXVhQm84TGo5aVZUY1YxSk5kMVVycC8wUkJ2bUFxak1VUk9xTlRkMUpMd2xOaWZhRk1qUG43czdJb250L1hIUkhFdWdNTGpLdUZQejRDR1IwQVpxNSsyaU5vY20zWEp3WXhvOGMxbzVJNlVHaFZueFp2bVFwY25oaXFURkVjOEVVeTBuVks3VmdjbGVSTHQwSTN1NkdrdzZicG9LV1d1eisxcjNjQiswN09WY2dUU0xndlNJWmhXMEM4TGNZWndTTWJVQlUydHRsR1QrNEdGWENLVFFkdlZoUU12QzA2WTRvNjQ5cnFyWmNRNWMwdkVIVzAvNklHVzhiZ0FRc1RqWXd2V21yQ21RQ1gzS2FLamkvV1VDQ3IwTTNEajVOc0Qxb2VoTHNTZFZTRnduNktYcm5zWXl2elJiWGVMNjJZYmhpWGZjTGFHZnRvc2taRkhUdmg0THUvVkRRZlJnS3VpZFFFUDFsVVJDOUdBWGRSUlJFNTFBdzZFdTdKNk9zWGo5TTVOVklMUy9RaWw3bWpFN2M4cjQ3MUI2eVlKQmVnSXNiRk9OUmV0WDg3NzlSL002NlFRYmVvSkg0bkVMNlUxNTdSN2lnamZpaVNiNDJJbDlZNEl4aUlhUUNhei9vZGJYQ2Rsd3luWlZORDg4WTN1UUpsUjlPUTU2bjZ6ajhBRTJuNXRBcFJ0OFVzN0swajcydkJFQWNQZ21BeTk0NGZqOW5mS0w1N29jMTMvMjQ1cnMzYUw3N3labzNlZGNINi83YmEzVC9sTlgzMnNPc01KV21MdnJ6RGQ3UDNWOEpnZVBxWU1qNTlkRk9Jdks3QThJdktRdzRiS2I5Ri9JQzMwZmFoTEtIRlJmc1gvZExQQnc4UGRQUHZjek1BUS9mMzVSd21aMTZUY01rUmFkcXkvSzdoa281S05rbkRUblhlNXM4SmFDbFZET1IranUrT3ZVNnEyRzlDNFQ1ZXZaRXdvVTlGOWZXU04wZWdsYVVTTDFKd3hX
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 2/3 MUhRNHVHT0pTbVpaTVJTQ2J5OG1PR3ZIOFFYUDhrTG9EbDB4SWxaSm1vNU1ZUWZkTURzMFNtRmhSZTdBdHBRcnkwTFlCRHFQK3ZlU2lKc2p5cDdrYjA3UjFCazVDRCtycWpGZDJNVVZySTh5anBvdGlDdXducTNoK3AwdG9LV21kVlYxZkFYL1N0WC9QbUdXbXpmQWc4UEliaCtGWHNDNXdBZExkTTNwdnQ4UHhHUm9tdUJPUVJ5cTNaTFpZNHZ6SFh2K3dwZ1VGTmhRM2xJTlVSSWRNRERCQUVzdWw1a3hRQWdxWmdkRXRvM2wwdlk2WHEzVVVMOElraVNjYWJhYWxwY3VrU1dULzE1MHFEV3hQZW9ydmVNVTNlaTlhYkZCMTBXS2lyUWtlRStDZUNyQWhUVWZVQUJpWTYwM3NlZFhXQ0kwNWZGMnY0bVY0dll6V2kvVTZpY1AxQ2tZUDNFdTJhWG96em1pK2pGWlJtQmRKdVo2VEpNeFgrWHFXeDNFK1MrTDVQSmt0aXF3RTNrbFpKS3YxbXN4V2hPU3JKQSt6Z2dKZkN3T2dvalVBY3MwODBMOWdhR2Qrejg0MDZQeDJuVWNaTmZGR1hVYnMzMkVEVDlDZG9OSkQ4WTRJbGQ1emNaZUJ2cllBVjFKMXhzZE1nb0U4MHFEZkQ4NHJMb2ZlVGw5TW1YcXVOZG0xNEJycC9hdWtHOXRyaHVrVXZZNVZxOUduVi9rWm94ZHFhRVBlb2lmMTUyZ29YSncxckR2TWUra3NNMlk4N3prTzdaemI0KzdPUTFEUlpxTzJRNmsvR1R6dDRJaWMxN2FpUFhhdEtGMUJjdVcxaFlIdU9mc2hpbnR4MnhaUmZBZWhRZU1ycjhBUjZHZ0RDbUVBWlFpM2ZLOFZEbUF3UlpGbXVxK1FYRFdFWEVPazJXeDdmUjljb01STzhoQTBqOEtGYzRtdE5CRFFudm9FZklIR1owa0Zuam0xTVhIdnUzNHRFbEVENEZERWVqYjZ5VDZpamUySUhMUWczOHQ0Um12RFk4azByRC8vRm9WL00yMEpRWE8rYVpneExPM3BDbFlnVzZOUjU5UnFENldsZWlJRUR3M0RLT1BSTUx6YlZPRUdISjhYdEg5QitYOW5meFRVcGhjR0hIc3RPSmx2YVUxR01JcWNXcHl0cDFzaU1ZaG5iL3dUUE1LUlREUTJxS29qZHptaW83Tkd2MzZlMjJzU2VJejdSeHVhKzlpSFFhcUUwTHNCTjgxczBZQ3VYdzhlZlJDWXFCbzZhMHB1WXBjeFJHZUZ2UTNBdWwvbWk4VS8vNE9XSWpBNzhmZmJRUUlLa1J3VzFPdnBHRFVPVVJxS2JzcVhULy8rVlYrS21jVDg5TU01OUZoaWF0Ty9YL0FTcVNVTnhIRHd1ck9qZXlSSjd0T2pvOXpUN0l4RUJxb25qbnZLTmxzTWw5ZUxSYktPRnF2bGZBVVB5Mlh5YU11QzQ1dThndTV3SzZzYzJ6aXhQc0c3RW5ST3hsMkNHZDl3c0k0Qjg4OTZ4MEZXemlVY3hSK0JQVElJZTRobE01UVdxYzZEWnVGc09RM1gwMmoyZXhUZHhQRk51UHg3R040WTJlRWlHdUNmbzhFSnVNd0NnaXo0M3RrbDVla3hwbUZ2QjAzOFhNbDIxU3JNL2V3emgwUGlMWmdSRGJoNTFhVjNtOVRoOTlUZDExZzhEVEhoWWpwVEUzRTNBS1VHTmd6M2Q1dHo2cklqRE84NFpBUnF5SXEwQzNYSWRoODJBS2JSbDBhbkhLT2Ni
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 3/3 eEljSmVndVVBMVl6V0hBaG1OYUVIZ0lCcGVsa3lPRGd6TVFoeWpBcUJ4UEFoL2ZGRVFVam9wcGFHcjU4aW1lWGNwV2FDK29RSUdxdHVveDBXZUhXUjZWbDlQZTRXb0doTEhibXNURzNlNDRENHlCbmtNMmREVTQveXNNTFArNDB0SzU2bWZJSzJ4ZVhGWDhuZ3A5cFhobGM2R3J2cEdoRTAzaWdzT1c1bmNBN2Y0MmRENXhKRDl6U0JCc1dOU0JWNE1qNWZxTTFuZFNJVXhaaXJCaFVxS1hORWZVc1VwbmVTZVhYVjdYYzlUckc3Vi9MalFDL0dzYXYxbC9YRTNxb3VKYnl3UmVFUDZjL1VkWi9UMFJEUWhIUytaUkZ3QmU5dlNJWnRHMGdDTklvVkNFTnVyUktFeG15K1Z5bnBCb1FaYXJKTXJpTlVrU1dvYkxaYkZhejBJZ2w5a3FwK3Q1RWxGS3d4bWR4MG01aW1aNVJHTHF1VzlqbjhhSmo0dXRqd3E0NzVXTFBKdGowWVAyNXFBSkFQNlF3RHlkWU5qWTV4SDZXdmZMNzc5K0hzaXVyaVJ2L0tQcmY5bnViRGpSQlhGZnk0NnMwamNwZTdSekxZRSszOWEvOFNDWTFKT0hPcGZsSjErZUVkbkVyVzVpWGVBUk11dGQyd1pNbWxkN0lIMXJxZlIrOGVJSTM2UFgvd1BlWExQdCIsInBheWxvYWRfc2hhMjU2IjoiNzlmNzg5NWE1Y2IxYjdlMTk2M2RiYjAzZmFiZmQxYWE1YzljNTNiN2Q2YjRiOTUwOWViZmRjYmI1YmVmNGQwNSIsInNjaGVtYV92ZXJzaW9uIjoiMS4xIn0=

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcPlate, SAME
In: Default Storey
Material: S355JR
Pset_NC1StepConverter - SchemaVersion: 1.1; ConverterVersion: 0.10.19-beta-dev; SourceFormat: STEP; SourceSHA256: aaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaa; PartId: P1; ProfileDesignation: PL10*100; ProfileType: B; MaterialGrade: S355JR; Quantity: 2; PayloadCodec: zlib+base64+json; PayloadSHA256: 684efd757839777b8487374d2160cb894c96c6e19079103efe4862010c2f1eb4; PayloadChunkCount: 3; MeshTolerance_mm: 0.2; PayloadChunk_0001: eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOck5XdHR5MnpnUy9SVVhIM2NsRnlsUm91Ujl5bFROeSs1c1ZXb3pieWtYQ3lSQkNXT1NVQUJRRnVQeWYrei83STl0TndDQ29DNjI0OHRrVWtsTU5uRnBkSisrd2c4QlVZcmsyNW8yU2dZM0Q0K1RnTFFGVTJuRk44SE4xOXRKa1BORzhWYkF4NjhQUVVseUd0d0UrMkFTM0xHbWdNZFAvNExuSFdkNk9vd29pR3Byb0FPMTRTcmZtc2R2d1UxNEhVNENRUXJXU3Z0eVR5dFk0U3MrZS85Z3k0TWU4RGg1dDlWbTRYUHJSZUhQWGhIWHUzMDBBdDlUb2FoSTRZZGt2SUVsdytzSS9xNm5HVlZrV2xDVWY4NjVLRmhERkUxTFFXcFF5MFBBQmR1d0pxM3I4U2E0UVVvT0REVVVqY2hkVDBaUzVNamZmYkw5ZEF2UUtBUzVaODBHdHlJTkhKY29ZRS8yT0tsM3BPbFNxYnFLcGd5eFVkQ1N0SlVDWmdzR0FNT3pwUG1Xc01aQXhld0JaNS8wVWh6UlNncEVnWERySWZnMXZBVzZaQVVTYTliQWkrcDIrR0xtUC9vYnNRSjNDYmE4b3RNd2pLYUhBSmpVYkNGSlRnL1RVdkI2V3RGU1RjMTBoMmtuV00wczBEbG9vcUNnRXRpVXdvaVNWSkxDNWlDQkt2VzN4TWt3bGxRVjdJZndJSm5rVlF0TFBjUFlueWVMdzVRMXVhQm84TGo5aVZUY1YxSk5kMVVycC8wUkJ2bUFxak1VUk9xTlRkMUpMd2xOaWZhRk1qUG43czdJb250L1hIUkhFdWdNTGpLdUZQejRDR1IwQVpxNSsyaU5vY20zWEp3WXhvOGMxbzVJNlVHaFZueFp2bVFwY25oaXFURkVjOEVVeTBuVks3VmdjbGVSTHQwSTN1NkdrdzZicG9LV1d1eisxcjNjQiswN09WY2dUU0xndlNJWmhXMEM4TGNZWndTTWJVQlUydHRsR1QrNEdGWENLVFFkdlZoUU12QzA2WTRvNjQ5cnFyWmNRNWMwdkVIVzAvNklHVzhiZ0FRc1RqWXd2V21yQ21RQ1gzS2FLamkvV1VDQ3IwTTNEajVOc0Qxb2VoTHNTZFZTRnduNktYcm5zWXl2elJiWGVMNjJZYmhpWGZjTGFHZnRvc2taRkhUdmg0THUvVkRRZlJnS3VpZFFFUDFsVVJDOUdBWGRSUlJFNTFBdzZFdTdKNk9zWGo5TTVOVklMUy9RaWw3bWpFN2M4cjQ3MUI2eVlKQmVnSXNiRk9OUmV0WDg3NzlSL002NlFRYmVvSkg0bkVMNlUxNTdSN2lnamZpaVNiNDJJbDlZNEl4aUlhUUNhei9vZGJYQ2Rsd3luWlZORDg4WTN1UUpsUjlPUTU2bjZ6ajhBRTJuNXRBcFJ0OFVzN0swajcydkJFQWNQZ21BeTk0NGZqOW5mS0w1N29jMTMvMjQ1cnMzYUw3N3labzNlZGNINi83YmEzVC9sTlgzMnNPc01KV21MdnJ6RGQ3UDNWOEpnZVBxWU1qNTlkRk9Jdks3QThJdktRdzRiS2I5Ri9JQzMwZmFoTEtIRlJmc1gvZExQQnc4UGRQUHZjek1BUS9mMzVSd21aMTZUY01rUmFkcXkvSzdoa281S05rbkRUblhlNXM4SmFDbFZET1IranUrT3ZVNnEyRzlDNFQ1ZXZaRXdvVTlGOWZXU04wZWdsYVVTTDFKd3hX; PayloadChunk_0002: MUhRNHVHT0pTbVpaTVJTQ2J5OG1PR3ZIOFFYUDhrTG9EbDB4SWxaSm1vNU1ZUWZkTURzMFNtRmhSZTdBdHBRcnkwTFlCRHFQK3ZlU2lKc2p5cDdrYjA3UjFCazVDRCtycWpGZDJNVVZySTh5anBvdGlDdXducTNoK3AwdG9LV21kVlYxZkFYL1N0WC9QbUdXbXpmQWc4UEliaCtGWHNDNXdBZExkTTNwdnQ4UHhHUm9tdUJPUVJ5cTNaTFpZNHZ6SFh2K3dwZ1VGTmhRM2xJTlVSSWRNRERCQUVzdWw1a3hRQWdxWmdkRXRvM2wwdlk2WHEzVVVMOElraVNjYWJhYWxwY3VrU1dULzE1MHFEV3hQZW9ydmVNVTNlaTlhYkZCMTBXS2lyUWtlRStDZUNyQWhUVWZVQUJpWTYwM3NlZFhXQ0kwNWZGMnY0bVY0dll6V2kvVTZpY1AxQ2tZUDNFdTJhWG96em1pK2pGWlJtQmRKdVo2VEpNeFgrWHFXeDNFK1MrTDVQSmt0aXF3RTNrbFpKS3YxbXN4V2hPU3JKQSt6Z2dKZkN3T2dvalVBY3MwODBMOWdhR2Qrejg0MDZQeDJuVWNaTmZGR1hVYnMzMkVEVDlDZG9OSkQ4WTRJbGQ1emNaZUJ2cllBVjFKMXhzZE1nb0U4MHFEZkQ4NHJMb2ZlVGw5TW1YcXVOZG0xNEJycC9hdWtHOXRyaHVrVXZZNVZxOUduVi9rWm94ZHFhRVBlb2lmMTUyZ29YSncxckR2TWUra3NNMlk4N3prTzdaemI0KzdPUTFEUlpxTzJRNmsvR1R6dDRJaWMxN2FpUFhhdEtGMUJjdVcxaFlIdU9mc2hpbnR4MnhaUmZBZWhRZU1ycjhBUjZHZ0RDbUVBWlFpM2ZLOFZEbUF3UlpGbXVxK1FYRFdFWEVPazJXeDdmUjljb01STzhoQTBqOEtGYzRtdE5CRFFudm9FZklIR1owa0Zuam0xTVhIdnUzNHRFbEVENEZERWVqYjZ5VDZpamUySUhMUWczOHQ0Um12RFk4azByRC8vRm9WL00yMEpRWE8rYVpneExPM3BDbFlnVzZOUjU5UnFENldsZWlJRUR3M0RLT1BSTUx6YlZPRUdISjhYdEg5QitYOW5meFRVcGhjR0hIc3RPSmx2YVUxR01JcWNXcHl0cDFzaU1ZaG5iL3dUUE1LUlREUTJxS29qZHptaW83Tkd2MzZlMjJzU2VJejdSeHVhKzlpSFFhcUUwTHNCTjgxczBZQ3VYdzhlZlJDWXFCbzZhMHB1WXBjeFJHZUZ2UTNBdWwvbWk4VS8vNE9XSWpBNzhmZmJRUUlLa1J3VzFPdnBHRFVPVVJxS2JzcVhULy8rVlYrS21jVDg5TU01OUZoaWF0Ty9YL0FTcVNVTnhIRHd1ck9qZXlSSjd0T2pvOXpUN0l4RUJxb25qbnZLTmxzTWw5ZUxSYktPRnF2bGZBVVB5Mlh5YU11QzQ1dThndTV3SzZzYzJ6aXhQc0c3RW5ST3hsMkNHZDl3c0k0Qjg4OTZ4MEZXemlVY3hSK0JQVElJZTRobE01UVdxYzZEWnVGc09RM1gwMmoyZXhUZHhQRk51UHg3R040WTJlRWlHdUNmbzhFSnVNd0NnaXo0M3RrbDVla3hwbUZ2QjAzOFhNbDIxU3JNL2V3emgwUGlMWmdSRGJoNTFhVjNtOVRoOTlUZDExZzhEVEhoWWpwVEUzRTNBS1VHTmd6M2Q1dHo2cklqRE84NFpBUnF5SXEwQzNYSWRoODJBS2JSbDBhbkhLT2Ni; PayloadChunk_0003: eEljSmVndVVBMVl6V0hBaG1OYUVIZ0lCcGVsa3lPRGd6TVFoeWpBcUJ4UEFoL2ZGRVFVam9wcGFHcjU4aW1lWGNwV2FDK29RSUdxdHVveDBXZUhXUjZWbDlQZTRXb0doTEhibXNURzNlNDRENHlCbmtNMmREVTQveXNNTFArNDB0SzU2bWZJSzJ4ZVhGWDhuZ3A5cFhobGM2R3J2cEdoRTAzaWdzT1c1bmNBN2Y0MmRENXhKRDl6U0JCc1dOU0JWNE1qNWZxTTFuZFNJVXhaaXJCaFVxS1hORWZVc1VwbmVTZVhYVjdYYzlUckc3Vi9MalFDL0dzYXYxbC9YRTNxb3VKYnl3UmVFUDZjL1VkWi9UMFJEUWhIUytaUkZ3QmU5dlNJWnRHMGdDTklvVkNFTnVyUktFeG15K1Z5bnBCb1FaYXJKTXJpTlVrU1dvYkxaYkZhejBJZ2w5a3FwK3Q1RWxGS3d4bWR4MG01aW1aNVJHTHF1VzlqbjhhSmo0dXRqd3E0NzVXTFBKdGowWVAyNXFBSkFQNlF3RHlkWU5qWTV4SDZXdmZMNzc5K0hzaXVyaVJ2L0tQcmY5bnViRGpSQlhGZnk0NnMwamNwZTdSekxZRSszOWEvOFNDWTFKT0hPcGZsSjErZUVkbkVyVzVpWGVBUk11dGQyd1pNbWxkN0lIMXJxZlIrOGVJSTM2UFgvd1BlWExQdCIsInBheWxvYWRfc2hhMjU2IjoiNzlmNzg5NWE1Y2IxYjdlMTk2M2RiYjAzZmFiZmQxYWE1YzljNTNiN2Q2YjRiOTUwOWViZmRjYmI1YmVmNGQwNSIsInNjaGVtYV92ZXJzaW9uIjoiMS4xIn0=
