Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: A1_ASSEMBLY.ifc
Time: 2026-09-12T11:44:06+00:00
Author: CWS Convertor
Organization: CWS Convertor
Written by: CWS Convertor v0.10.19-beta-dev
Made in: CWS Convertor v0.10.19-beta-dev
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 1/2 eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOckZXT3VQMjdnUi8xY0s5V3U4SVNsS0l2ZWJMd2dLdEJjMDZBSXRpa05BOERHMGVhdUhqNUozNHd2eXYzZW9sK1c5dlJZSWVuY0xMeXdPcWVFOGZ2UHlsMHdQZzdiSEJ0cWh6KzYvZkgyVDZiTUxnNnE3UTNiL3c2YzNtZTNhb1R2SGZsMDlRUndnS3Z6cVE5ZG05eG01by9pUk93T0Qzamw0eXRLeExyclE2Z0dVajdvQjVKeDFNUnhDcTVvR09aRTc4bWIrUjZhZmxmNGMwZ1gwaG54WnlJbEVWL0xQVy9LODlRbmxkbEUvaC9hUXJ0SnQydzE2UVBGV3NadVRiaStxSHk0MXFPQlFhZ2RlbitzQmhYVUJ0VSs2S0h2VVlYbGxwUzdyaVQyeTBNTVphY2tVRms2SkFWNEc4eWxVRWkwNVhvMUhhdDI2M3VvVDRLRlQ3SDRFbXpaVUE4T3hTekw0RVB0QjZmWlFweE1SbnNMbVFud1J5ZmNaN3ZSSGdFSFo3dHdPMlQxZDFyNkxqVVpDdHMvWE0rMjVNUkNuUTVmR2RQWE1iSURtVkNkM3ZOQjlDQU1heE5TZGZaeTgveFRnZVg0blNXTndOeUVBbFZMOVViT2lUQkxoT1IrZ2Rnb2xkb0JtbU40OVFJZXF4Y3ZvZ3I2SHh0UVgxZWcyZU9pSEcySnc2WTVzVHpPOFozTTBQaVoxYURaNXJPdkRhSy8xWWlvbzhjN1NTbk5lRWxtVWhBdFdGS0tRdEtoS2FibHpCZlc2TU1RdzUyeFJXT0ZJbFROYkNFa0phT1RyZFkvS0lING5FZkQ2MVl6di92V2c5ZzhQN3o5ODkvMi8xY2Y5dTcvdC8vSmUvVE1Kcytod2xjUWJuZk1jT1F0T0t1T0ZxR3pwaWN1RnI3U3p2QlQ0Qk16bVducFpjVEM4ZE1DWWxRV0taZkVyQVVMSEZISS9vRm5pRUx5Mjg4cnF0bXNET2wvMTRZQWhkSTRKQlFac21kUzNydkl5MXhXeHdrcG1PYmVzUWtFcVZqampHU0hhdTBwSXFablEycUpVeERqUUZ0S0ZxNkxCMjBtcGM3cjFIQk9zajdvLzRoWlFVckd5TFBOSzAwS1hvcUtHUzExVjRFbFpPaUVaUWJJM3dvTE1Ld29BaEVIT0t5OG9zMVR6Qk9NR1hOQnF1SnlTMlBwMHFsR1g1TWEzbjNkbyt0TjRvdS8xWVEwWmsrSmlBdVpIT2tXS08wK1JzbGdtdXgvaUdWS0lJSWpERTZpVEhwSzRvdzNmN3VuYmgvMkg5MHBXUkpSRlJiMWd6UGxTY2xaU1dVank5cnUvZi9nVGZENTFjVkI3cXNhekg3K25SRkZDRkZGYm5lOG0yeXloT0lWZnhNQnpRd3duRldGa3NzTEFrSnd4VGFpa3BXQ3lwSVVGUjNJdVBMcTQ1TWFqbThwYzBMTGlCUmNGUUVrc3FkQitscGFJRVVIR3VKMTVsV0NFTUZMTFhKUTBCMXBCeFV2RXVUV2VJNmpCK2R5Z013VWlRWlRlT3VPc2NVSlloaUVoVFpIQTNZZWZNWmd2WXpaaXN1QVNTWmk3VTN4bVBrSi8zSzNnMnExS3BmZVduRFlaQ1J4RytPOEJ4SmVHL1NOUTJka0JCa1JtQk4xOEl6YTlydnR2QitkTEk5ejkyQ1B3L2lBTVVuQ2x6S1dodFBLRmQ0NmhKWTNndXVRNW94cFJSdzFhWEhN
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 2/2 aHBNNnR6b1d0QUZNY0NDZDBVYmtYR0tRRXMvTzNZL0JsYmRqVWpOOE1tN2JHSzRPZjBZRThHLzJZUFByYmdoTXJjd3k2Um00UGVWSDg5UjhibWpwRTdlQm01d2FpU2JRdFFOTnlxWnpwTGNUZUxXNVR4Y2F5ZjFua2R5U0pDSUk3QWdVSFdUcVQrNG81VHRHM0hBb3BXVzRGMWpzaWpORUN2ZTVLeURFUGFTbVlyOUtsUDUzMXhITEF0Z3UxWUw4dmVrZDRxVm1yMFJSLzV1eTY0Y1BTOC8wcXpPYm1iRG9GaGZEb1NMZHpUcm9kejBXMU05b1dPK29yajRGQXBPVDVyelIwaVBvZTZ0Um9PV3lRN2RCRjlSd2lURDB3dm9MeW9OVnhNMkJEZG0xQkZ2dU5mZHR6YXF6bXJhL0prQ2VNbWsxVHVZYkUyQ0toWFZNN2RnUUVTVXc5RnZhdE5MdFBmWEY2Wk5mSC9QcklsOGU1cDEyNnhtUWdqMDNyQVZRVFVwUHZZNWRhenZId3pRWm15empUUSt1N1NZMGEya1BLZkJoaGQyVDhZOU1YdjRGNGx0cGtsUGJtMmhOMjN0Z0tJOStaN1FqazljVFlFNjRONFF0eTdKS0wwM0x1M3E3RUplTnZkbTZNamJFVkVoekdLM3Y5clA2YkRzOWdYckhMbGJveHlqT0V3M0U2a2J6VDFVdTRobWJFLzRxWWF5SmIvWXAxQkJBazJYSVk0VEpXeTJ3YjdNdnArLzJtTEkwOU5rcWhNSnNkMWVyOGtUU0c1b1oyYmNVbjFyWk9rOHY4M0NIWTBpaVZGaTZOUVJoWWp3ZTFZbWl5MGpqTGplc0d2YWV1RTlNMDVMMWlRdm9hQ1NteWtnUzdhVmt5bnN0UGlkOTFFbWhRMUVtaHg4TjZIWkltaFRhME9WL2F6czFqMHk5U2FKclZ4bWwwQnM0NEVRM0hZQjliRE55ck9ndDRzQWpBb1VzRFRiYUJsSU9wNWt6aCtBcm1lcncxK1h2N0V1YWQxdW5vVnVxWWIyWnB0cFJOVFBUbmlOVUdKVVQvRGMzc25hL2oyUk1PNGVNZHIweGEvOGNwWmN3L3RqdTBjem41c2kwa2MwZXQ2N3A3eGp3NnR1aGYwOXg2aEVadmZoK2dkL1EyR1NQdDJwRnZ0amFEMkxzcmVkVUdFN0d6REh4UkVFR3hOYWJNU0VOSUNkN21BbWM5cWd0Wll0Y2l1TGNjbTVjU2E0ZkVsVFI1SmJHVUlNdHoyNTlQYzB5TlErOHk2dW82T0wzb0NERjJ5dzhlczVKcjJaaURNM1U2SHNhK1k4ekRPb1orZlBrNkJnZjdpNTMvWWJ3M0svYzE0RmVDbVVGNGJyRWFkUFVUa240Nm83T3Z2eGM4NjloaTBDNTE0MmI1SDJHZnVDMD0iLCJwYXlsb2FkX3NoYTI1NiI6ImE5ZThhZWFkZTgxZDQ4OTVjM2FkNzY0YTE1N2U2OWI5NGNmM2I1YWNkOTQzYTg2ZjdmZDBhYTUxYTMxMjNmNDYiLCJzY2hlbWFfdmVyc2lvbiI6IjEuMSJ9

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcElementAssembly, A1
In: Default Storey
Pset_CWSAssemblyPackage - AssemblyMark: A1; CompositionSHA256: 1810fdc17a446095604825585915769c4dd51fa5b0b2ddc55c8d0732c58910ea; ManifestSHA256: fba34332c8407bf887c6f0d38f7adc46838fe2c3a9f974eb46de22c95ddccc95; PartCount: 1

# IfcPlate, P1
In: Default Storey
Material: S355JR
Pset_NC1StepConverter - SchemaVersion: 1.1; ConverterVersion: 0.10.19-beta-dev; SourceFormat: CWSC; SourceFile: BOM export; SourceSHA256: 387dc2ef5508146412b9b006efc3855c1a596f5f84fc45fd670c9f849b3794bf; PartId: assembly:A1; ProfileDesignation: ASSEMBLY; ProfileType: ASSEMBLY; Quantity: 1; PayloadCodec: zlib+base64+json; PayloadSHA256: 6180b624499cbb3160bdf2ffe91a1eb4cbef8fd4b013f27b2e47e2713db6ab4c; PayloadChunkCount: 2; MeshTolerance_mm: 0.2; PayloadChunk_0001: eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOckZXT3VQMjdnUi8xY0s5V3U4SVNsS0l2ZWJMd2dLdEJjMDZBSXRpa05BOERHMGVhdUhqNUozNHd2eXYzZW9sK1c5dlJZSWVuY0xMeXdPcWVFOGZ2UHlsMHdQZzdiSEJ0cWh6KzYvZkgyVDZiTUxnNnE3UTNiL3c2YzNtZTNhb1R2SGZsMDlRUndnS3Z6cVE5ZG05eG01by9pUk93T0Qzamw0eXRLeExyclE2Z0dVajdvQjVKeDFNUnhDcTVvR09aRTc4bWIrUjZhZmxmNGMwZ1gwaG54WnlJbEVWL0xQVy9LODlRbmxkbEUvaC9hUXJ0SnQydzE2UVBGV3NadVRiaStxSHk0MXFPQlFhZ2RlbitzQmhYVUJ0VSs2S0h2VVlYbGxwUzdyaVQyeTBNTVphY2tVRms2SkFWNEc4eWxVRWkwNVhvMUhhdDI2M3VvVDRLRlQ3SDRFbXpaVUE4T3hTekw0RVB0QjZmWlFweE1SbnNMbVFud1J5ZmNaN3ZSSGdFSFo3dHdPMlQxZDFyNkxqVVpDdHMvWE0rMjVNUkNuUTVmR2RQWE1iSURtVkNkM3ZOQjlDQU1heE5TZGZaeTgveFRnZVg0blNXTndOeUVBbFZMOVViT2lUQkxoT1IrZ2Rnb2xkb0JtbU40OVFJZXF4Y3ZvZ3I2SHh0UVgxZWcyZU9pSEcySnc2WTVzVHpPOFozTTBQaVoxYURaNXJPdkRhSy8xWWlvbzhjN1NTbk5lRWxtVWhBdFdGS0tRdEtoS2FibHpCZlc2TU1RdzUyeFJXT0ZJbFROYkNFa0phT1RyZFkvS0lING5FZkQ2MVl6di92V2c5ZzhQN3o5ODkvMi8xY2Y5dTcvdC8vSmUvVE1Kcytod2xjUWJuZk1jT1F0T0t1T0ZxR3pwaWN1RnI3U3p2QlQ0Qk16bVducFpjVEM4ZE1DWWxRV0taZkVyQVVMSEZISS9vRm5pRUx5Mjg4cnF0bXNET2wvMTRZQWhkSTRKQlFac21kUzNydkl5MXhXeHdrcG1PYmVzUWtFcVZqampHU0hhdTBwSXFablEycUpVeERqUUZ0S0ZxNkxCMjBtcGM3cjFIQk9zajdvLzRoWlFVckd5TFBOSzAwS1hvcUtHUzExVjRFbFpPaUVaUWJJM3dvTE1Ld29BaEVIT0t5OG9zMVR6Qk9NR1hOQnF1SnlTMlBwMHFsR1g1TWEzbjNkbyt0TjRvdS8xWVEwWmsrSmlBdVpIT2tXS08wK1JzbGdtdXgvaUdWS0lJSWpERTZpVEhwSzRvdzNmN3VuYmgvMkg5MHBXUkpSRlJiMWd6UGxTY2xaU1dVank5cnUvZi9nVGZENTFjVkI3cXNhekg3K25SRkZDRkZGYm5lOG0yeXloT0lWZnhNQnpRd3duRldGa3NzTEFrSnd4VGFpa3BXQ3lwSVVGUjNJdVBMcTQ1TWFqbThwYzBMTGlCUmNGUUVrc3FkQitscGFJRVVIR3VKMTVsV0NFTUZMTFhKUTBCMXBCeFV2RXVUV2VJNmpCK2R5Z013VWlRWlRlT3VPc2NVSlloaUVoVFpIQTNZZWZNWmd2WXpaaXN1QVNTWmk3VTN4bVBrSi8zSzNnMnExS3BmZVduRFlaQ1J4RytPOEJ4SmVHL1NOUTJka0JCa1JtQk4xOEl6YTlydnR2QitkTEk5ejkyQ1B3L2lBTVVuQ2x6S1dodFBLRmQ0NmhKWTNndXVRNW94cFJSdzFhWEhN; PayloadChunk_0002: aHBNNnR6b1d0QUZNY0NDZDBVYmtYR0tRRXMvTzNZL0JsYmRqVWpOOE1tN2JHSzRPZjBZRThHLzJZUFByYmdoTXJjd3k2Um00UGVWSDg5UjhibWpwRTdlQm01d2FpU2JRdFFOTnlxWnpwTGNUZUxXNVR4Y2F5ZjFua2R5U0pDSUk3QWdVSFdUcVQrNG81VHRHM0hBb3BXVzRGMWpzaWpORUN2ZTVLeURFUGFTbVlyOUtsUDUzMXhITEF0Z3UxWUw4dmVrZDRxVm1yMFJSLzV1eTY0Y1BTOC8wcXpPYm1iRG9GaGZEb1NMZHpUcm9kejBXMU05b1dPK29yajRGQXBPVDVyelIwaVBvZTZ0Um9PV3lRN2RCRjlSd2lURDB3dm9MeW9OVnhNMkJEZG0xQkZ2dU5mZHR6YXF6bXJhL0prQ2VNbWsxVHVZYkUyQ0toWFZNN2RnUUVTVXc5RnZhdE5MdFBmWEY2Wk5mSC9QcklsOGU1cDEyNnhtUWdqMDNyQVZRVFVwUHZZNWRhenZId3pRWm15empUUSt1N1NZMGEya1BLZkJoaGQyVDhZOU1YdjRGNGx0cGtsUGJtMmhOMjN0Z0tJOStaN1FqazljVFlFNjRONFF0eTdKS0wwM0x1M3E3RUplTnZkbTZNamJFVkVoekdLM3Y5clA2YkRzOWdYckhMbGJveHlqT0V3M0U2a2J6VDFVdTRobWJFLzRxWWF5SmIvWXAxQkJBazJYSVk0VEpXeTJ3YjdNdnArLzJtTEkwOU5rcWhNSnNkMWVyOGtUU0c1b1oyYmNVbjFyWk9rOHY4M0NIWTBpaVZGaTZOUVJoWWp3ZTFZbWl5MGpqTGplc0d2YWV1RTlNMDVMMWlRdm9hQ1NteWtnUzdhVmt5bnN0UGlkOTFFbWhRMUVtaHg4TjZIWkltaFRhME9WL2F6czFqMHk5U2FKclZ4bWwwQnM0NEVRM0hZQjliRE55ck9ndDRzQWpBb1VzRFRiYUJsSU9wNWt6aCtBcm1lcncxK1h2N0V1YWQxdW5vVnVxWWIyWnB0cFJOVFBUbmlOVUdKVVQvRGMzc25hL2oyUk1PNGVNZHIweGEvOGNwWmN3L3RqdTBjem41c2kwa2MwZXQ2N3A3eGp3NnR1aGYwOXg2aEVadmZoK2dkL1EyR1NQdDJwRnZ0amFEMkxzcmVkVUdFN0d6REh4UkVFR3hOYWJNU0VOSUNkN21BbWM5cWd0Wll0Y2l1TGNjbTVjU2E0ZkVsVFI1SmJHVUlNdHoyNTlQYzB5TlErOHk2dW82T0wzb0NERjJ5dzhlczVKcjJaaURNM1U2SHNhK1k4ekRPb1orZlBrNkJnZjdpNTMvWWJ3M0svYzE0RmVDbVVGNGJyRWFkUFVUa240Nm83T3Z2eGM4NjloaTBDNTE0MmI1SDJHZnVDMD0iLCJwYXlsb2FkX3NoYTI1NiI6ImE5ZThhZWFkZTgxZDQ4OTVjM2FkNzY0YTE1N2U2OWI5NGNmM2I1YWNkOTQzYTg2ZjdmZDBhYTUxYTMxMjNmNDYiLCJzY2hlbWFfdmVyc2lvbiI6IjEuMSJ9
