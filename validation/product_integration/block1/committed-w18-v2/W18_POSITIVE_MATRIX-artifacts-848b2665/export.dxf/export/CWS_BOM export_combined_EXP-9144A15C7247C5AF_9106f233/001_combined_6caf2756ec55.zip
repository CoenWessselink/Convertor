Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: A1_ASSEMBLY.ifc
Time: 2026-09-12T11:44:08+00:00
Author: CWS Convertor
Organization: CWS Convertor
Written by: CWS Convertor v0.10.19-beta-dev
Made in: CWS Convertor v0.10.19-beta-dev
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 1/2 eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOckZXRzF2NUxnTi9pdUYrM1dUbFd6TGt2SXR0MWdVYUcvUlF4ZG9VUndXQmlWUk03cjRaVTcySkp0YjdIOHY1YmZ4NUhMdGw5NWVrQ0FqNm8ya0hwSVA1MHNHNHdqMjJHSTNEdG5kbDY5dk1qaTdNTlpOZjhqdWZ2ejBKck45Ti9ibk9HeWpSNHdqeHByK0RhSHZzcnVNM1hMNjFUY0dSN2h4K0ppbFpYMTBvWU1SYXgraFJUbzU2Mk00aEs1dVd6cUozYkkzeXg4ZCtybUd6eUZkd0svRXo2czRpZmdtL21VdlhxWStrZDR1d2xQb0R1a3E2THAraEpIVTI5UnVUOUE5MThQNDNHQWRIR250ME1PNUdVbFpGOGo2WkV0dGp4RFdMWnQwSGMvSDB4RXdua21XWEdIeGxBNmd5M0JaUlVhU0o2ZXJhVWtEblJzc25KQVduV0wvRTlvMFViYzRIdnVrZ3c5eEdHdm9EazFhRWZFeDdDNmtqU1MreTJobU9DS090ZTNQM1pqZDhYWHMrOWdDQ2JMN1lsdlRuVnVEY1Y3MDNKcStXUTRic1QwMTZUbGUyRDZHa1J4aW10NCt6Sy8vR1BCcDJaTzBNVFNiRUVCRzFjTVJjbEVsaldpZEQ5aTRtalIyU0c2WTl4NndKOVBpOC9RRXc0Q3RhWjdyRnJyZ2NSaXZoTUdsTzdKN250RTl1Nlh4SVpuRHMvbkYraUZNL3RvdTVvb3o3eXlYVUpZVjA2SmlwY3FGVUVKeklTdHRTK2NFOXlBTU03bHpWZ2lySEpORmJvWFNuQ0hRdVI0R01vYndPNnRBMTI5dWZQZXZqL1g5eDQvdlAzejMvYi9ySCs3Zi9lMytMKy9yZnlabFZoc3VtaFJlS3Vta2NUbm9TckpLZUdrVW9BYWhLbFA0M0lOSGhTV052UmNHRFJqbHE1SlpaU3ZKalN3VElDQ21rUHVSM0JMSDRNRXVJd3RkM3dWNi9Ib0lCd3FoYzB3b01HaXJaTDUxMHVzQ1pEcEs1N1lzYlM3TG9wQzVjTWJuaklGM1Vta051UUt3U2xwbUhJSkZrZTBNZFovOWJOUTUzWHFPQ2RaSEdJNDBoWnpKdktxcVFnSVhVQ2xTbG95UUVqMnJLcWQwemtqc2piS29DOGtSa2VWWWxOSXJubHNPWllKeGl5NUFQVDZma3RxaGhRTytmZXpjN1hJcERnTkoxbWd4S1NSbVRQN0E1eUJ4NXpsSVZxZGtkeDZhQVZONEVJRERJOVluR0pPcWsvL2Uzdk8zSCs4L3ZLKzFaS29Ta251VjU4NVh1c3dycm9WbWI3LzcrNGMvNGVkVEg4ZjZudGZUMmgrKzU2em1qTldzM3R1N3FMaUc0Ung2a1lMT2pUR2M2b2pUSVJzRWhNNk5RTTFjNlZIcXdudUpsVlNxUW1Pa1E2MUxVM3FycXNKVXhsbUxSZTZFQm9leUFDNUxVZkFwWmxkZ08xOUk1Ung0WnBtdG1DSHZDcTNLSEFUVGVWR0NLQW5ZWG1ySGVWVXB4aFRJa25sYkZCWnphMHc2Sy94Q2dmdzhaYUt5eUxra0VlWHRGSnNYU04yUUV4R0c5RXhiSHB1ZGc0NmkrbHVBNzZWRHZ4VVM0WFJxeUxDRXJiZTlIWEc4R2NhSTBQNGhvSHpwaE51ZkJnTGNINE05bEdDbGNKeDJLY2E5cXp4eUtDb21VQWlwRFZRbGViN2dVa2dsd0Zh
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 2/2 aVV0YnlncndNbXZLd3RTK3d4eGxsNUIzMmZNVGhlTE5ENEdyVTZ4aDhXUTkyZGVKM3c2WnQ2TXJnRjNUUW1TMDhwQmY5ZmNGSjFUZ0dhT2kwajRVUWYvM0hUbFlmSXIzVzFjd1ZSSk5xZTRDbTRWb3QweTdDM2pWdVU1V21Vdis4NnU5WVVoRlY2UmlLRW5YbHFHakozSlhjU2l4UmFFbzZWaGtvbURJR1ZHSEJWVmdnU2JUS3ZVeVgvbnlHK2NpUnFCWlprWDliOUU3d3FoZXJKbGY4dWN3dkV6NnNQTzgzWWJZUXNua1ZDdVhwSWQyTmM5cmRsSVdTTndhc3VPRmVlb29BUmtvVnYwSGlDUFVETm9sY09TTEZkdXhqL1JRaXpyeVh0cEErNUhXYURFVENMclJqOWQvRTFaNFNtVnFtdmlaSG5paHFka1J5QzRtSkZwRmZFd1U3SWprbEpsNUZYSlZuZDRrTHA0LzU1V054K1ZpdUh4Y2V1ekxGNUNCUFJQV0FkUnNTc2ZleFR6UnpXbncxUWRreUx2TFErWDQybzhIdWtESWZSZGd0bTM3eStWOTVCZkVzVVdQUzl1cmFFN0Z0b3I5MDduTHNCT1J0eGNRRE54TDRRaHo3OU1ScHVEQzJpM0ROK0x1WksyZFRiSVVFaCtuS0FaN3EvMmJERTVwWC9IS1I3cHp5aE9Gd25GZWsxK21iTlZ4RE8rRi9ROHdsa1czdmVxbkw4MktDeTFRdHMzMndyNnZ2N25kbGFlTFZwRVZOMmV4WWI0OC9pYWJRM01rdTlIcysyamFwVzFrKzl3UzIxRDZsZ1V1dER3WFd3NkhlTURSN2FlcmZwbkZMcjFkZnVxUzVzWHZGaGZ3MUVVbTAxS3dvY2wzbFphRS9wZk11N0w4bFZXZURIZzdiZFNTYURkckpsbnhwZTdlMFNyOUtvYWsvbXpyUUJUaFRGelFlZzMzb0tIQXY1cXpnb1NLQWh6NDFNZGtPVWc3bm1qT0g0eXVZRytqVzlONzdUWlIzT2dmUmJkSXAzeXphN0NXN21Cak9rYW9OYVVqdk43Ykw2M3lkMXA2bzhaN3VlS1c3K2o5MkpsUCtzZjJoVzhySmwzMGhXWmcwTkUzL1JIbjBib3huL0pwNjFTTzJzUHRPZ04veTYyUk1zZ3NUMzAzdG1xOTNGL0hGR3JMRjV1aUZZSXFYUkVWeW93MWpGUkwzVmRUZmNSQzY4c0lycWhpbElQSkM5Vi9UU0p0Q1VoMUpmUDdjRGVmVEVsTlRvN3UydDlBRUI2dU5HR08vZnNteEdMbVZqU1U0WGNxVU9QR09LUTlERE1PMCtkTDZCdnVybWYvaHZEZmI2VnZBYndLemdQRGNVVFhvbTBjUy9YeW14NzU4Ui9BRXNhT2dYZXZHMWZBL0pUMjJNQT09IiwicGF5bG9hZF9zaGEyNTYiOiIyYjlmYTAzZDZkNzNlYzc0NmMxM2I3NWY2NmQ0MzBmNWI2NjUxZGY1YjY2M2Q1Mjc5ZGFmZThiZGJmYTVmZDYyIiwic2NoZW1hX3ZlcnNpb24iOiIxLjEifQ==

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcElementAssembly, A1
In: Default Storey
Pset_CWSAssemblyPackage - AssemblyMark: A1; CompositionSHA256: 1810fdc17a446095604825585915769c4dd51fa5b0b2ddc55c8d0732c58910ea; ManifestSHA256: 3f787d7bd2a967065f7b8ae9a586b3f2fafe8e49a5ff5bebab8f640c8c671b74; PartCount: 1

# IfcPlate, P1
In: Default Storey
Material: S355JR
Pset_NC1StepConverter - SchemaVersion: 1.1; ConverterVersion: 0.10.19-beta-dev; SourceFormat: CWSC; SourceFile: BOM export; SourceSHA256: 387dc2ef5508146412b9b006efc3855c1a596f5f84fc45fd670c9f849b3794bf; PartId: assembly:A1; ProfileDesignation: ASSEMBLY; ProfileType: ASSEMBLY; Quantity: 1; PayloadCodec: zlib+base64+json; PayloadSHA256: ee4a58da9c273a64910a9326cb60245dff2cb3f4850884bcf82a94ddba00d584; PayloadChunkCount: 2; MeshTolerance_mm: 0.2; PayloadChunk_0001: eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOckZXRzF2NUxnTi9pdUYrM1dUbFd6TGt2SXR0MWdVYUcvUlF4ZG9VUndXQmlWUk03cjRaVTcySkp0YjdIOHY1YmZ4NUhMdGw5NWVrQ0FqNm8ya0hwSVA1MHNHNHdqMjJHSTNEdG5kbDY5dk1qaTdNTlpOZjhqdWZ2ejBKck45Ti9ibk9HeWpSNHdqeHByK0RhSHZzcnVNM1hMNjFUY0dSN2h4K0ppbFpYMTBvWU1SYXgraFJUbzU2Mk00aEs1dVd6cUozYkkzeXg4ZCtybUd6eUZkd0svRXo2czRpZmdtL21VdlhxWStrZDR1d2xQb0R1a3E2THAraEpIVTI5UnVUOUE5MThQNDNHQWRIR250ME1PNUdVbFpGOGo2WkV0dGp4RFdMWnQwSGMvSDB4RXdua21XWEdIeGxBNmd5M0JaUlVhU0o2ZXJhVWtEblJzc25KQVduV0wvRTlvMFViYzRIdnVrZ3c5eEdHdm9EazFhRWZFeDdDNmtqU1MreTJobU9DS090ZTNQM1pqZDhYWHMrOWdDQ2JMN1lsdlRuVnVEY1Y3MDNKcStXUTRic1QwMTZUbGUyRDZHa1J4aW10NCt6Sy8vR1BCcDJaTzBNVFNiRUVCRzFjTVJjbEVsaldpZEQ5aTRtalIyU0c2WTl4NndKOVBpOC9RRXc0Q3RhWjdyRnJyZ2NSaXZoTUdsTzdKN250RTl1Nlh4SVpuRHMvbkYraUZNL3RvdTVvb3o3eXlYVUpZVjA2SmlwY3FGVUVKeklTdHRTK2NFOXlBTU03bHpWZ2lySEpORmJvWFNuQ0hRdVI0R01vYndPNnRBMTI5dWZQZXZqL1g5eDQvdlAzejMvYi9ySCs3Zi9lMytMKy9yZnlabFZoc3VtaFJlS3Vta2NUbm9TckpLZUdrVW9BYWhLbFA0M0lOSGhTV052UmNHRFJqbHE1SlpaU3ZKalN3VElDQ21rUHVSM0JMSDRNRXVJd3RkM3dWNi9Ib0lCd3FoYzB3b01HaXJaTDUxMHVzQ1pEcEs1N1lzYlM3TG9wQzVjTWJuaklGM1Vta051UUt3U2xwbUhJSkZrZTBNZFovOWJOUTUzWHFPQ2RaSEdJNDBoWnpKdktxcVFnSVhVQ2xTbG95UUVqMnJLcWQwemtqc2piS29DOGtSa2VWWWxOSXJubHNPWllKeGl5NUFQVDZma3RxaGhRTytmZXpjN1hJcERnTkoxbWd4S1NSbVRQN0E1eUJ4NXpsSVZxZGtkeDZhQVZONEVJRERJOVluR0pPcWsvL2Uzdk8zSCs4L3ZLKzFaS29Ta251VjU4NVh1c3dycm9WbWI3LzcrNGMvNGVkVEg4ZjZudGZUMmgrKzU2em1qTldzM3R1N3FMaUc0Ung2a1lMT2pUR2M2b2pUSVJzRWhNNk5RTTFjNlZIcXdudUpsVlNxUW1Pa1E2MUxVM3FycXNKVXhsbUxSZTZFQm9leUFDNUxVZkFwWmxkZ08xOUk1Ung0WnBtdG1DSHZDcTNLSEFUVGVWR0NLQW5ZWG1ySGVWVXB4aFRJa25sYkZCWnphMHc2Sy94Q2dmdzhaYUt5eUxra0VlWHRGSnNYU04yUUV4R0c5RXhiSHB1ZGc0NmkrbHVBNzZWRHZ4VVM0WFJxeUxDRXJiZTlIWEc4R2NhSTBQNGhvSHpwaE51ZkJnTGNINE05bEdDbGNKeDJLY2E5cXp4eUtDb21VQWlwRFZRbGViN2dVa2dsd0Zh; PayloadChunk_0002: aVV0YnlncndNbXZLd3RTK3d4eGxsNUIzMmZNVGhlTE5ENEdyVTZ4aDhXUTkyZGVKM3c2WnQ2TXJnRjNUUW1TMDhwQmY5ZmNGSjFUZ0dhT2kwajRVUWYvM0hUbFlmSXIzVzFjd1ZSSk5xZTRDbTRWb3QweTdDM2pWdVU1V21Vdis4NnU5WVVoRlY2UmlLRW5YbHFHakozSlhjU2l4UmFFbzZWaGtvbURJR1ZHSEJWVmdnU2JUS3ZVeVgvbnlHK2NpUnFCWlprWDliOUU3d3FoZXJKbGY4dWN3dkV6NnNQTzgzWWJZUXNua1ZDdVhwSWQyTmM5cmRsSVdTTndhc3VPRmVlb29BUmtvVnYwSGlDUFVETm9sY09TTEZkdXhqL1JRaXpyeVh0cEErNUhXYURFVENMclJqOWQvRTFaNFNtVnFtdmlaSG5paHFka1J5QzRtSkZwRmZFd1U3SWprbEpsNUZYSlZuZDRrTHA0LzU1V054K1ZpdUh4Y2V1ekxGNUNCUFJQV0FkUnNTc2ZleFR6UnpXbncxUWRreUx2TFErWDQybzhIdWtESWZSZGd0bTM3eStWOTVCZkVzVVdQUzl1cmFFN0Z0b3I5MDduTHNCT1J0eGNRRE54TDRRaHo3OU1ScHVEQzJpM0ROK0x1WksyZFRiSVVFaCtuS0FaN3EvMmJERTVwWC9IS1I3cHp5aE9Gd25GZWsxK21iTlZ4RE8rRi9ROHdsa1czdmVxbkw4MktDeTFRdHMzMndyNnZ2N25kbGFlTFZwRVZOMmV4WWI0OC9pYWJRM01rdTlIcysyamFwVzFrKzl3UzIxRDZsZ1V1dER3WFd3NkhlTURSN2FlcmZwbkZMcjFkZnVxUzVzWHZGaGZ3MUVVbTAxS3dvY2wzbFphRS9wZk11N0w4bFZXZURIZzdiZFNTYURkckpsbnhwZTdlMFNyOUtvYWsvbXpyUUJUaFRGelFlZzMzb0tIQXY1cXpnb1NLQWh6NDFNZGtPVWc3bm1qT0g0eXVZRytqVzlONzdUWlIzT2dmUmJkSXAzeXphN0NXN21Cak9rYW9OYVVqdk43Ykw2M3lkMXA2bzhaN3VlS1c3K2o5MkpsUCtzZjJoVzhySmwzMGhXWmcwTkUzL1JIbjBib3huL0pwNjFTTzJzUHRPZ04veTYyUk1zZ3NUMzAzdG1xOTNGL0hGR3JMRjV1aUZZSXFYUkVWeW93MWpGUkwzVmRUZmNSQzY4c0lycWhpbElQSkM5Vi9UU0p0Q1VoMUpmUDdjRGVmVEVsTlRvN3UydDlBRUI2dU5HR08vZnNteEdMbVZqU1U0WGNxVU9QR09LUTlERE1PMCtkTDZCdnVybWYvaHZEZmI2VnZBYndLemdQRGNVVFhvbTBjUy9YeW14NzU4Ui9BRXNhT2dYZXZHMWZBL0pUMjJNQT09IiwicGF5bG9hZF9zaGEyNTYiOiIyYjlmYTAzZDZkNzNlYzc0NmMxM2I3NWY2NmQ0MzBmNWI2NjUxZGY1YjY2M2Q1Mjc5ZGFmZThiZGJmYTVmZDYyIiwic2NoZW1hX3ZlcnNpb24iOiIxLjEifQ==
