Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: SAME_e107266637a1.ifc
Time: 2026-09-12T11:44:07+00:00
Author: CWS Convertor
Organization: CWS Convertor
Written by: CWS Convertor v0.10.19-beta-dev
Made in: CWS Convertor v0.10.19-beta-dev
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 1/3 eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOck5XdHR5MnpnUy9SVVhIM2NsRnlsUm91Ujl5bFROeSs1c1ZXb3pieWtYQ3lSQkNXT1NVQUJRRnVQeWYrei83STl0TndDQ29DNjI0OHRrVWtsTU5uRnBkSisrd2c4QlVZcmsyNW8yU2dZM0Q0K1RnTFFGVTJuRk44SE4xOXRKa1BORzhWYkF4NjhQUVVseUd0d0UrMkFTM0xHbWdNZFAvNExuSFdkNk9vd29pR3Byb0FPMTRTcmZtc2R2d1UxNEhVNENRUXJXU3Z0eVR5dFk0U3MrZS85Z3k0TWU4RGg1dDlWbTRYUHJSZUhQWGhIWHUzMDBBdDlUb2FoSTRZZGt2SUVsdytzSS9xNm5HVlZrV2xDVWY4NjVLRmhERkUxTFFXcFF5MFBBQmR1d0pxM3I4U2E0UVVvT0REVVVqY2hkVDBaUzVNamZmYkw5ZEF2UUtBUzVaODBHdHlJTkhKY29ZRS8yT0tsM3BPbFNxYnFLcGd5eFVkQ1N0SlVDWmdzR0FNT3pwUG1Xc01aQXhld0JaNS8wVWh6UlNncEVnWERySWZnMXZBVzZaQVVTYTliQWkrcDIrR0xtUC9vYnNRSjNDYmE4b3RNd2pLYUhBSmpVYkNGSlRnL1RVdkI2V3RGU1RjMTBoMmtuV00wczBEbG9vcUNnRXRpVXdvaVNWSkxDNWlDQkt2VzN4TWt3bGxRVjdJZndJSm5rVlF0TFBjUFlueWVMdzVRMXVhQm84TGo5aVZUY1YxSk5kMVVycC8wUkJ2bUFxak1VUk9xTlRkMUpMd2xOaWZhRk1qUG43czdJb250L1hIUkhFdWdNTGpLdUZQejRDR1IwQVpxNSsyaU5vY20zWEp3WXhvOGMxbzVJNlVHaFZueFp2bVFwY25oaXFURkVjOEVVeTBuVks3VmdjbGVSTHQwSTN1NkdrdzZicG9LV1d1eisxcjNjQiswN09WY2dUU0xndlNJWmhXMEM4TGNZWndTTWJVQlUydHRsR1QrNEdGWENLVFFkdlZoUU12QzA2WTRvNjQ5cnFyWmNRNWMwdkVIVzAvNklHVzhiZ0FRc1RqWXd2V21yQ21RQ1gzS2FLamkvV1VDQ3IwTTNEajVOc0Qxb2VoTHNTZFZTRnduNktYcm5zWXl2elJiWGVMNjJZYmhpWGZjTGFHZnRvc2taRkhUdmg0THUvVkRRZlJnS3VpZFFFUDFsVVJDOUdBWGRSUlJFNTFBdzZFdTdKNk9zWGo5TTVOVklMUy9RaWw3bWpFN2M4cjQ3MUI2eVlKQmVnSXNiRk9OUmV0WDg3NzlSL002NlFRYmVvSkg0bkVMNlUxNTdSN2lnamZpaVNiNDJJbDlZNEl4aUlhUUNhei9vZGJYQ2Rsd3luWlZORDg4WTN1UUpsUjlPUTU2bjZ6ajhBRTJuNXRBcFJ0OFVzN0swajcydkJFQWNQZ21BeTk0NGZqOW5mS0w1N29jMTMvMjQ1cnMzYUw3N3labzNlZGNINi83YmEzVC9sTlgzMnNPc01KV21MdnJ6RGQ3UDNWOEpnZVBxWU1qNTlkRk9Jdks3QThJdktRdzRiS2I5Ri9JQzMwZmFoTEtIRlJmc1gvZExQQnc4UGRQUHZjek1BUS9mMzVSd21aMTZUY01rUmFkcXkvSzdoa281S05rbkRUblhlNXM4SmFDbFZET1IranUrT3ZVNnEyRzlDNFQ1ZXZaRXdvVTlGOWZXU04wZWdsYVVTTDFKd3hX
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 2/3 MUhRNHVHT0pTbVpaTVJTQ2J5OG1PR3ZIOFFYUDhrTG9EbDB4SWxaSm1vNU1ZUWZkTURzMFNtRmhSZTdBdHBRcnkwTFlCRHFQK3ZlU2lKc2p5cDdrYjA3UjFCazVDRCtycWpGZDJNVVZySTh5anBvdGlDdXducTNoK3AwdG9LV21kVlYxZkFYL1N0WC9QbUdXbXpmQWc4UEliaCtGWHNDNXdBZExkTTNwdnQ4UHhHUm9tdUJPUVJ5cTNaTFpZNHZ6SFh2K3dwZ1VGTmhRM2xJTlVSSWRNRERCQUVzdWw1a3hRQWdxWmdkRXRvM2wwdlk2WHEzVVVMOElraVNjYWJhYWxwY3VrU1dULzE1MHFEV3hQZW9ydmVNVTNlaTlhYkZCMTBXS2lyUWtlRStDZUNyQWhUVWZVQUJpWTYwM3NlZFhXQ0kwNWZGMnY0bVY0dll6V2kvVTZpY1AxQ2tZUDNFdTJhWG96em1pK2pGWlJtQmRKdVo2VEpNeFgrWHFXeDNFK1MrTDVQSmt0aXF3RTNrbFpKS3YxbXN4V2hPU3JKQSt6Z2dKZkN3T2dvalVBY3MwODBMOWdhR2Qrejg0MDZQeDJuVWNaTmZGR1hVYnMzMkVEVDlDZG9OSkQ4WTRJbGQ1emNaZUJ2cllBVjFKMXhzZE1nb0U4MHFEZkQ4NHJMb2ZlVGw5TW1YcXVOZG0xNEJycC9hdWtHOXRyaHVrVXZZNVZxOUduVi9rWm94ZHFhRVBlb2lmMTUyZ29YSncxckR2TWUra3NNMlk4N3prTzdaemI0KzdPUTFEUlpxTzJRNmsvR1R6dDRJaWMxN2FpUFhhdEtGMUJjdVcxaFlIdU9mc2hpbnR4MnhaUmZBZWhRZU1ycjhBUjZHZ0RDbUVBWlFpM2ZLOFZEbUF3UlpGbXVxK1FYRFdFWEVPazJXeDdmUjljb01STzhoQTBqOEtGYzRtdE5CRFFudm9FZklIR1owa0Zuam0xTVhIdnUzNHRFbEVENEZERWVqYjZ5VDZpamUySUhMUWczOHQ0Um12RFk4azByRC8vRm9WL00yMEpRWE8rYVpneExPM3BDbFlnVzZOUjU5UnFENldsZWlJRUR3M0RLT1BSTUx6YlZPRUdISjhYdEg5QitYOW5meFRVcGhjR0hIc3RPSmx2YVUxR01JcWNXcHl0cDFzaU1ZaG5iL3dUUE1LUlREUTJxS29qZHptaW83Tkd2MzZlMjJzU2VJejdSeHVhKzlpSFFhcUUwTHNCTjgxczBZQ3VYdzhlZlJDWXFCbzZhMHB1WXBjeFJHZUZ2UTNBdWwvbWk4VS8vNE9XSWpBNzhmZmJRUUlLa1J3VzFPdnBHRFVPVVJxS2JzcVhULy8rVlYrS21jVDg5TU01OUZoaWF0Ty9YL0FTcVNVTnhIRHd1ck9qZXlSSjd0T2pvOXpUN0l4RUJxb25qbnZLTmxzTWw5ZUxSYktPRnF2bGZBVVB5Mlh5YU11QzQ1dThndTV3SzZzYzJ6aXhQc0c3RW5ST3hsMkNHZDl3c0k0Qjg4OTZ4MEZXemlVY3hSK0JQVElJZTRobE01UVdxYzZEWnVGc09RM1gwMmoyZXhUZHhQRk5tUHc5REcrTTdIQVJEZkRQMGVBRVhHWUJRUlo4Nyt5Uzh2UVkwN0MzZ3laK3JtUzdhaFhtZnZhWnd5SHhGc3lJQnR5ODZ0SzdUZXJ3ZStydWF5eWVocGh3TVoycGliZ2JnRklERzRiN3U4MDVkZGtSaG5jY01nSTFaRVhhaFRwa3V3OGJBTlBvUzZOVGpsSE9O
Comment: NC1_STEP_CONVERTER_PAYLOAD_V1 3/3 d21PRW5RWHFBYXM1akJnd3pFdENEd0VnOHZTeVpIQndSbUlReFJnVkk0bmdZOXZDaUlLUjhVME5MVjgrUlRQTG1VcnRCZFVvRUJWVy9XWTZMUERMSS9LeTJudmNEVUR3dGh0VFdMamJuZWNCOFpBenlFYnVocWMveFVHbG45Y2FlbGM5VFBrRlRZdnJpcCtUNFcrVXJ5eXVkQlYzOGpRaVNaeHdXRkw4enVBZG44Yk9wODRrcDg1SkFnMkxPckFxOEdSY24xRzZ6dXBFS1lzUmRnd0tkRkxtaVBxV0tXenZKUExMcS9yT2VyMWpkby9GeG9CL2pXTjM2dy9yaVoxVWZHdFpRSXZDSC9PL3FPcy9wNklCb1NqSmZPb0N3QXZlM3BFczJoYXdCR2tVQ2hDRy9Wb0ZDYXo1WEk1VDBpMElNdFZFbVh4bWlRSkxjUGxzbGl0WnlHUXkyeVYwL1U4aVNpbDRZek80NlJjUmJNOElqSDEzTGV4VCtQRXg4WFdSd1hjOThwRm5zMng2RUY3YzlBRUFIOUlZSjVPTUd6czh3aDlyZnZsOTE4L0QyUlhWNUkzL3RIMXYyeDNOcHpvZ3JpdlpVZFc2WnVVUGRxNWxrQ2ZiK3ZmZUJCTTZzbERuY3Z5a3kvUGlHemlWamV4THZBSW1mV3ViUU1temFzOWtMNjFWSHEvZUhHRTc5SHIvd0hsZ0xQdSIsInBheWxvYWRfc2hhMjU2IjoiMTQ2NWUwM2ZmMTg3ZWVjYjIxZDczYWJmNmViM2UyMzhhNDVlODk1NmE2ZTY0NjU0N2QwNjEwMWM4MTI0YzBiZCIsInNjaGVtYV92ZXJzaW9uIjoiMS4xIn0=

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcPlate, SAME
In: Default Storey
Material: S355JR
Pset_NC1StepConverter - SchemaVersion: 1.1; ConverterVersion: 0.10.19-beta-dev; SourceFormat: STEP; SourceSHA256: aaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaa; PartId: P1; ProfileDesignation: PL10*100; ProfileType: B; MaterialGrade: S355JR; Quantity: 2; PayloadCodec: zlib+base64+json; PayloadSHA256: 841d7325be849b6c39da206326b0e00cc74d30cf6016c3c8de7efc6ba458f63e; PayloadChunkCount: 3; MeshTolerance_mm: 0.2; PayloadChunk_0001: eyJjb2RlYyI6InpsaWIrYmFzZTY0K2pzb24iLCJwYXlsb2FkX2I2NCI6ImVOck5XdHR5MnpnUy9SVVhIM2NsRnlsUm91Ujl5bFROeSs1c1ZXb3pieWtYQ3lSQkNXT1NVQUJRRnVQeWYrei83STl0TndDQ29DNjI0OHRrVWtsTU5uRnBkSisrd2c4QlVZcmsyNW8yU2dZM0Q0K1RnTFFGVTJuRk44SE4xOXRKa1BORzhWYkF4NjhQUVVseUd0d0UrMkFTM0xHbWdNZFAvNExuSFdkNk9vd29pR3Byb0FPMTRTcmZtc2R2d1UxNEhVNENRUXJXU3Z0eVR5dFk0U3MrZS85Z3k0TWU4RGg1dDlWbTRYUHJSZUhQWGhIWHUzMDBBdDlUb2FoSTRZZGt2SUVsdytzSS9xNm5HVlZrV2xDVWY4NjVLRmhERkUxTFFXcFF5MFBBQmR1d0pxM3I4U2E0UVVvT0REVVVqY2hkVDBaUzVNamZmYkw5ZEF2UUtBUzVaODBHdHlJTkhKY29ZRS8yT0tsM3BPbFNxYnFLcGd5eFVkQ1N0SlVDWmdzR0FNT3pwUG1Xc01aQXhld0JaNS8wVWh6UlNncEVnWERySWZnMXZBVzZaQVVTYTliQWkrcDIrR0xtUC9vYnNRSjNDYmE4b3RNd2pLYUhBSmpVYkNGSlRnL1RVdkI2V3RGU1RjMTBoMmtuV00wczBEbG9vcUNnRXRpVXdvaVNWSkxDNWlDQkt2VzN4TWt3bGxRVjdJZndJSm5rVlF0TFBjUFlueWVMdzVRMXVhQm84TGo5aVZUY1YxSk5kMVVycC8wUkJ2bUFxak1VUk9xTlRkMUpMd2xOaWZhRk1qUG43czdJb250L1hIUkhFdWdNTGpLdUZQejRDR1IwQVpxNSsyaU5vY20zWEp3WXhvOGMxbzVJNlVHaFZueFp2bVFwY25oaXFURkVjOEVVeTBuVks3VmdjbGVSTHQwSTN1NkdrdzZicG9LV1d1eisxcjNjQiswN09WY2dUU0xndlNJWmhXMEM4TGNZWndTTWJVQlUydHRsR1QrNEdGWENLVFFkdlZoUU12QzA2WTRvNjQ5cnFyWmNRNWMwdkVIVzAvNklHVzhiZ0FRc1RqWXd2V21yQ21RQ1gzS2FLamkvV1VDQ3IwTTNEajVOc0Qxb2VoTHNTZFZTRnduNktYcm5zWXl2elJiWGVMNjJZYmhpWGZjTGFHZnRvc2taRkhUdmg0THUvVkRRZlJnS3VpZFFFUDFsVVJDOUdBWGRSUlJFNTFBdzZFdTdKNk9zWGo5TTVOVklMUy9RaWw3bWpFN2M4cjQ3MUI2eVlKQmVnSXNiRk9OUmV0WDg3NzlSL002NlFRYmVvSkg0bkVMNlUxNTdSN2lnamZpaVNiNDJJbDlZNEl4aUlhUUNhei9vZGJYQ2Rsd3luWlZORDg4WTN1UUpsUjlPUTU2bjZ6ajhBRTJuNXRBcFJ0OFVzN0swajcydkJFQWNQZ21BeTk0NGZqOW5mS0w1N29jMTMvMjQ1cnMzYUw3N3labzNlZGNINi83YmEzVC9sTlgzMnNPc01KV21MdnJ6RGQ3UDNWOEpnZVBxWU1qNTlkRk9Jdks3QThJdktRdzRiS2I5Ri9JQzMwZmFoTEtIRlJmc1gvZExQQnc4UGRQUHZjek1BUS9mMzVSd21aMTZUY01rUmFkcXkvSzdoa281S05rbkRUblhlNXM4SmFDbFZET1IranUrT3ZVNnEyRzlDNFQ1ZXZaRXdvVTlGOWZXU04wZWdsYVVTTDFKd3hX; PayloadChunk_0002: MUhRNHVHT0pTbVpaTVJTQ2J5OG1PR3ZIOFFYUDhrTG9EbDB4SWxaSm1vNU1ZUWZkTURzMFNtRmhSZTdBdHBRcnkwTFlCRHFQK3ZlU2lKc2p5cDdrYjA3UjFCazVDRCtycWpGZDJNVVZySTh5anBvdGlDdXducTNoK3AwdG9LV21kVlYxZkFYL1N0WC9QbUdXbXpmQWc4UEliaCtGWHNDNXdBZExkTTNwdnQ4UHhHUm9tdUJPUVJ5cTNaTFpZNHZ6SFh2K3dwZ1VGTmhRM2xJTlVSSWRNRERCQUVzdWw1a3hRQWdxWmdkRXRvM2wwdlk2WHEzVVVMOElraVNjYWJhYWxwY3VrU1dULzE1MHFEV3hQZW9ydmVNVTNlaTlhYkZCMTBXS2lyUWtlRStDZUNyQWhUVWZVQUJpWTYwM3NlZFhXQ0kwNWZGMnY0bVY0dll6V2kvVTZpY1AxQ2tZUDNFdTJhWG96em1pK2pGWlJtQmRKdVo2VEpNeFgrWHFXeDNFK1MrTDVQSmt0aXF3RTNrbFpKS3YxbXN4V2hPU3JKQSt6Z2dKZkN3T2dvalVBY3MwODBMOWdhR2Qrejg0MDZQeDJuVWNaTmZGR1hVYnMzMkVEVDlDZG9OSkQ4WTRJbGQ1emNaZUJ2cllBVjFKMXhzZE1nb0U4MHFEZkQ4NHJMb2ZlVGw5TW1YcXVOZG0xNEJycC9hdWtHOXRyaHVrVXZZNVZxOUduVi9rWm94ZHFhRVBlb2lmMTUyZ29YSncxckR2TWUra3NNMlk4N3prTzdaemI0KzdPUTFEUlpxTzJRNmsvR1R6dDRJaWMxN2FpUFhhdEtGMUJjdVcxaFlIdU9mc2hpbnR4MnhaUmZBZWhRZU1ycjhBUjZHZ0RDbUVBWlFpM2ZLOFZEbUF3UlpGbXVxK1FYRFdFWEVPazJXeDdmUjljb01STzhoQTBqOEtGYzRtdE5CRFFudm9FZklIR1owa0Zuam0xTVhIdnUzNHRFbEVENEZERWVqYjZ5VDZpamUySUhMUWczOHQ0Um12RFk4azByRC8vRm9WL00yMEpRWE8rYVpneExPM3BDbFlnVzZOUjU5UnFENldsZWlJRUR3M0RLT1BSTUx6YlZPRUdISjhYdEg5QitYOW5meFRVcGhjR0hIc3RPSmx2YVUxR01JcWNXcHl0cDFzaU1ZaG5iL3dUUE1LUlREUTJxS29qZHptaW83Tkd2MzZlMjJzU2VJejdSeHVhKzlpSFFhcUUwTHNCTjgxczBZQ3VYdzhlZlJDWXFCbzZhMHB1WXBjeFJHZUZ2UTNBdWwvbWk4VS8vNE9XSWpBNzhmZmJRUUlLa1J3VzFPdnBHRFVPVVJxS2JzcVhULy8rVlYrS21jVDg5TU01OUZoaWF0Ty9YL0FTcVNVTnhIRHd1ck9qZXlSSjd0T2pvOXpUN0l4RUJxb25qbnZLTmxzTWw5ZUxSYktPRnF2bGZBVVB5Mlh5YU11QzQ1dThndTV3SzZzYzJ6aXhQc0c3RW5ST3hsMkNHZDl3c0k0Qjg4OTZ4MEZXemlVY3hSK0JQVElJZTRobE01UVdxYzZEWnVGc09RM1gwMmoyZXhUZHhQRk5tUHc5REcrTTdIQVJEZkRQMGVBRVhHWUJRUlo4Nyt5Uzh2UVkwN0MzZ3laK3JtUzdhaFhtZnZhWnd5SHhGc3lJQnR5ODZ0SzdUZXJ3ZStydWF5eWVocGh3TVoycGliZ2JnRklERzRiN3U4MDVkZGtSaG5jY01nSTFaRVhhaFRwa3V3OGJBTlBvUzZOVGpsSE9O; PayloadChunk_0003: d21PRW5RWHFBYXM1akJnd3pFdENEd0VnOHZTeVpIQndSbUlReFJnVkk0bmdZOXZDaUlLUjhVME5MVjgrUlRQTG1VcnRCZFVvRUJWVy9XWTZMUERMSS9LeTJudmNEVUR3dGh0VFdMamJuZWNCOFpBenlFYnVocWMveFVHbG45Y2FlbGM5VFBrRlRZdnJpcCtUNFcrVXJ5eXVkQlYzOGpRaVNaeHdXRkw4enVBZG44Yk9wODRrcDg1SkFnMkxPckFxOEdSY24xRzZ6dXBFS1lzUmRnd0tkRkxtaVBxV0tXenZKUExMcS9yT2VyMWpkby9GeG9CL2pXTjM2dy9yaVoxVWZHdFpRSXZDSC9PL3FPcy9wNklCb1NqSmZPb0N3QXZlM3BFczJoYXdCR2tVQ2hDRy9Wb0ZDYXo1WEk1VDBpMElNdFZFbVh4bWlRSkxjUGxzbGl0WnlHUXkyeVYwL1U4aVNpbDRZek80NlJjUmJNOElqSDEzTGV4VCtQRXg4WFdSd1hjOThwRm5zMng2RUY3YzlBRUFIOUlZSjVPTUd6czh3aDlyZnZsOTE4L0QyUlhWNUkzL3RIMXYyeDNOcHpvZ3JpdlpVZFc2WnVVUGRxNWxrQ2ZiK3ZmZUJCTTZzbERuY3Z5a3kvUGlHemlWamV4THZBSW1mV3ViUU1temFzOWtMNjFWSHEvZUhHRTc5SHIvd0hsZ0xQdSIsInBheWxvYWRfc2hhMjU2IjoiMTQ2NWUwM2ZmMTg3ZWVjYjIxZDczYWJmNmViM2UyMzhhNDVlODk1NmE2ZTY0NjU0N2QwNjEwMWM4MTI0YzBiZCIsInNjaGVtYV92ZXJzaW9uIjoiMS4xIn0=
